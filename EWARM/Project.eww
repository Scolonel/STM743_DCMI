<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\BASE32H743_DCMI.ewp</path>
  </project>
  <batchBuild />
</workspace>
